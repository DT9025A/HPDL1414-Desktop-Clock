# Keil uVision project hpdl.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5206AD STC
  cpu: IRAM(0-0xFF) IROM(0-0x17FF) CLOCK(45000000)
  output: hpdl +hex
  c flags: Optimize=8 SizeSpeed=1
  group HPDL1414TMR
    ./: STARTUP.A51 hpdl1414.c hpdl.c VIIC_C51.C ds3231.c stc12c2052isp.c ds.asm
